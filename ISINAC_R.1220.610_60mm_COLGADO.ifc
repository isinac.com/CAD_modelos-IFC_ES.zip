Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2] - R.1220.610.60 - www.isinac.com
File name: ISINAC_R.1220.610_60mm_COLGADO.ifc
Time: 2026-08-11T16:15:45
Author: ISINAC ACOUSTIC WORLD S.L.U.
Organization: ISINAC ACOUSTIC WORLD S.L.U.
Written by: IfcOpenShell 0.8.5-1c5b825
Made in: IfcOpenShell 0.8.5-1c5b825

# IfcFurniture, ISINAC R.1220.610.60 Colgado
Description: Rectángulo acústico espuma mineral ISINAC · Suspendido con cable
ISINAC_Producto - Fabricante: ISINAC ACOUSTIC WORLD S.L.U.; CIF: ESB27853381; Web: www.isinac.com; Codigo ISINAC: R.1220.610.60; Forma: Rectángulo; Largo (mm): 1220; Ancho (mm): 610; Espesor (mm): 60; Montaje: Suspendido con cable; Material: espuma mineral ISINAC; Tipo de material: Espuma mineral de celda abierta; Densidad (kg/m3): 9; Reaccion al fuego: C-s2,d0 (EN 13501-1); Unidades por palet: 36; Puntos de anclaje: 4; Posicion de los anclajes (mm): (122, 61); (122, 549); (1098, 61); (1098, 549); Suspension: Panel suspendido. El cable NO va modelado: la altura de suspension la fija su proyecto. El modelo original traia 3000 mm de cable, que dejaban el objeto en mas de 3 m de alto y no caben en un techo normal.
ISINAC_Acustica - Absorcion acustica: Este producto NO tiene ensayo de absorcion propio. El unico ensayo en montaje suspendido de ISINAC es el de 40 mm; colgar un panel cambia su absorcion y el cambio no es proporcional al espesor, asi que no se traslada el valor de otro espesor. Consulte a ISINAC si necesita el dato para su proyecto.
