Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2] - HEX.610.60 - www.isinac.com
File name: ISINAC_HEX.610_60mm_COLGADO.ifc
Time: 2026-08-11T16:15:47
Author: ISINAC ACOUSTIC WORLD S.L.U.
Organization: ISINAC ACOUSTIC WORLD S.L.U.
Written by: IfcOpenShell 0.8.5-1c5b825
Made in: IfcOpenShell 0.8.5-1c5b825

# IfcFurniture, ISINAC HEX.610.60 Colgado
Description: Hexágono acústico espuma mineral ISINAC · Suspendido con cable
ISINAC_Producto - Fabricante: ISINAC ACOUSTIC WORLD S.L.U.; CIF: ESB27853381; Web: www.isinac.com; Codigo ISINAC: HEX.610.60; Forma: Hexágono; Largo (mm): 610; Espesor (mm): 60; Montaje: Suspendido con cable; Material: espuma mineral ISINAC; Tipo de material: Espuma mineral de celda abierta; Densidad (kg/m3): 9; Reaccion al fuego: C-s2,d0 (EN 13501-1); Unidades por palet: 72; Puntos de anclaje: 3; Posicion de los anclajes (mm): (-224, 130); (0, -259); (224, 130); Suspension: Panel suspendido. El cable NO va modelado: la altura de suspension la fija su proyecto. El modelo original traia 3000 mm de cable, que dejaban el objeto en mas de 3 m de alto y no caben en un techo normal.
ISINAC_Acustica - Absorcion acustica: Este producto NO tiene ensayo de absorcion propio. El unico ensayo en montaje suspendido de ISINAC es el de 40 mm; colgar un panel cambia su absorcion y el cambio no es proporcional al espesor, asi que no se traslada el valor de otro espesor. Consulte a ISINAC si necesita el dato para su proyecto.
