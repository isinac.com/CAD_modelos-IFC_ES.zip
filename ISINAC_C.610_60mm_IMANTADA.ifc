Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2] - C.610.60 - www.isinac.com
File name: ISINAC_C.610_60mm_IMANTADA.ifc
Time: 2026-08-11T16:15:44
Author: ISINAC ACOUSTIC WORLD S.L.U.
Organization: ISINAC ACOUSTIC WORLD S.L.U.
Written by: IfcOpenShell 0.8.5-1c5b825
Made in: IfcOpenShell 0.8.5-1c5b825

# IfcCovering, ISINAC C.610.60 Imantada
Description: Cuadrado acústico espuma mineral ISINAC · Fijación magnética
ISINAC_Producto - Fabricante: ISINAC ACOUSTIC WORLD S.L.U.; CIF: ESB27853381; Web: www.isinac.com; Codigo ISINAC: C.610.60; Forma: Cuadrado; Largo (mm): 610; Ancho (mm): 610; Espesor (mm): 60; Montaje: Fijación magnética; Material: espuma mineral ISINAC; Tipo de material: Espuma mineral de celda abierta; Densidad (kg/m3): 9; Reaccion al fuego: C-s2,d0 (EN 13501-1); Unidades por palet: 72
ISINAC_Acustica - Coeficiente alpha_w: 1.0; Laboratorio de ensayo: Fundacion Tecnalia R&I; Fecha del ensayo: 2024_01_10; Numero de informe: 110259-1; Montaje ISO 354 Anexo B: No consta en el informe de ensayo; Norma de ensayo: EN ISO 354; Norma de evaluacion: UNE-EN ISO 11654; Area de probeta ensayada (m2): 12.08; Camara de aire del ensayo (mm): 0; Separacion entre paneles en el ensayo (mm): 30; Aviso sobre la junta: El ensayo se hizo con los paneles separados 30 mm entre si. Con esa junta queda canto de panel expuesto al sonido: un revestimiento CONTINUO, sin junta, absorbe algo menos que este valor.; Base del dato acustico: Ensayo realizado con fijacion adhesiva. La fijacion magnetica deja el panel en la misma posicion acustica —en contacto con el soporte, sin camara de aire—, que es el montaje tipo A de EN ISO 354. El valor se publica por esa equivalencia de montaje, no por un ensayo propio.; Absorcion alpha 125 Hz: 0.3; Absorcion alpha 250 Hz: 0.8; Absorcion alpha 500 Hz: 1.0; Absorcion alpha 1000 Hz: 1.0; Absorcion alpha 2000 Hz: 1.0; Absorcion alpha 4000 Hz: 1.0
