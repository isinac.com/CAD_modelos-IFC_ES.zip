Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2] - HEX.1220.40 - www.isinac.com
File name: ISINAC_HEX.1220_40mm_ADHESIVO.ifc
Time: 2026-08-11T16:15:47
Author: ISINAC ACOUSTIC WORLD S.L.U.
Organization: ISINAC ACOUSTIC WORLD S.L.U.
Written by: IfcOpenShell 0.8.5-1c5b825
Made in: IfcOpenShell 0.8.5-1c5b825

# IfcCovering, ISINAC HEX.1220.40 Adhesivo
Description: Hexágono acústico espuma mineral ISINAC · Adhesivo directo a soporte
ISINAC_Producto - Fabricante: ISINAC ACOUSTIC WORLD S.L.U.; CIF: ESB27853381; Web: www.isinac.com; Codigo ISINAC: HEX.1220.40; Forma: Hexágono; Largo (mm): 1220; Espesor (mm): 40; Montaje: Adhesivo directo a soporte; Material: espuma mineral ISINAC; Tipo de material: Espuma mineral de celda abierta; Densidad (kg/m3): 9; Reaccion al fuego: C-s2,d0 (EN 13501-1); Unidades por palet: 19
ISINAC_Acustica - Coeficiente alpha_w: 0.75; Laboratorio de ensayo: Fundacion Tecnalia R&I; Fecha del ensayo: 2018_07_31; Numero de informe: B2018-LACUS-IN-27 III; Montaje ISO 354 Anexo B: No consta en el informe de ensayo; Norma de ensayo: EN ISO 354; Norma de evaluacion: UNE-EN ISO 11654; Indicadores de forma: MH; Area de probeta ensayada (m2): 12.08; Camara de aire del ensayo (mm): 0; Separacion entre paneles en el ensayo (mm): 30; Aviso sobre la junta: El ensayo se hizo con los paneles separados 30 mm entre si. Con esa junta queda canto de panel expuesto al sonido: un revestimiento CONTINUO, sin junta, absorbe algo menos que este valor.; Base del dato acustico: Ensayo realizado sobre este mismo espesor y este mismo montaje. La forma y el tamaño del panel no intervienen: EN ISO 354 mide el sistema material + espesor + montaje sobre una superficie de 12.08 m2.; Absorcion alpha 125 Hz: 0.15; Absorcion alpha 250 Hz: 0.45; Absorcion alpha 500 Hz: 0.8; Absorcion alpha 1000 Hz: 1.0; Absorcion alpha 2000 Hz: 1.0; Absorcion alpha 4000 Hz: 1.0
