Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2] - C.800.60 - www.isinac.com
File name: ISINAC_C.800_60mm_COLGADO.ifc
Time: 2026-08-11T16:15:44
Author: ISINAC ACOUSTIC WORLD S.L.U.
Organization: ISINAC ACOUSTIC WORLD S.L.U.
Written by: IfcOpenShell 0.8.5-1c5b825
Made in: IfcOpenShell 0.8.5-1c5b825

# IfcFurniture, ISINAC C.800.60 Colgado
Description: Cuadrado acústico espuma mineral ISINAC · Suspendido con cable
ISINAC_Producto - Fabricante: ISINAC ACOUSTIC WORLD S.L.U.; CIF: ESB27853381; Web: www.isinac.com; Codigo ISINAC: C.800.60; Forma: Cuadrado; Largo (mm): 800; Ancho (mm): 800; Espesor (mm): 60; Montaje: Suspendido con cable; Material: espuma mineral ISINAC; Tipo de material: Espuma mineral de celda abierta; Densidad (kg/m3): 9; Reaccion al fuego: C-s2,d0 (EN 13501-1); Unidades por palet: 24; Puntos de anclaje: 4; Posicion de los anclajes (mm): (80, 80); (80, 720); (720, 80); (720, 720); Suspension: Panel suspendido. El cable NO va modelado: la altura de suspension la fija su proyecto. El modelo original traia 3000 mm de cable, que dejaban el objeto en mas de 3 m de alto y no caben en un techo normal.
ISINAC_Acustica - Absorcion acustica: Este producto NO tiene ensayo de absorcion propio. El unico ensayo en montaje suspendido de ISINAC es el de 40 mm; colgar un panel cambia su absorcion y el cambio no es proporcional al espesor, asi que no se traslada el valor de otro espesor. Consulte a ISINAC si necesita el dato para su proyecto.
