Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2] - CIR.1220.40 - www.isinac.com
File name: ISINAC_CIR.1220_40mm_COLGADO.ifc
Time: 2026-08-11T16:15:46
Author: ISINAC ACOUSTIC WORLD S.L.U.
Organization: ISINAC ACOUSTIC WORLD S.L.U.
Written by: IfcOpenShell 0.8.5-1c5b825
Made in: IfcOpenShell 0.8.5-1c5b825

# IfcFurniture, ISINAC CIR.1220.40 Colgado
Description: Círculo acústico espuma mineral ISINAC · Suspendido con cable
ISINAC_Producto - Fabricante: ISINAC ACOUSTIC WORLD S.L.U.; CIF: ESB27853381; Web: www.isinac.com; Codigo ISINAC: CIR.1220.40; Forma: Círculo; Largo (mm): 1220; Espesor (mm): 40; Montaje: Suspendido con cable; Material: espuma mineral ISINAC; Tipo de material: Espuma mineral de celda abierta; Densidad (kg/m3): 9; Reaccion al fuego: C-s2,d0 (EN 13501-1); Unidades por palet: 19; Puntos de anclaje: 3; Posicion de los anclajes (mm): (-229, -396); (-229, 396); (458, 0); Suspension: Panel suspendido. El cable NO va modelado: la altura de suspension la fija su proyecto. El modelo original traia 3000 mm de cable, que dejaban el objeto en mas de 3 m de alto y no caben en un techo normal.
ISINAC_Acustica - Coeficiente alpha_w: 0.65; Laboratorio de ensayo: Fundacion Tecnalia R&I; Fecha del ensayo: 2019_04_10; Numero de informe: B2019-LACUS-IN-54 I; Montaje ISO 354 Anexo B: No consta en el informe de ensayo; Norma de ensayo: EN ISO 354; Norma de evaluacion: UNE-EN ISO 11654; Indicadores de forma: MH; Area de probeta ensayada (m2): 12.08; Camara de aire del ensayo (mm): 400; Base del dato acustico: Ensayo realizado sobre este mismo espesor y este mismo montaje. La forma y el tamaño del panel no intervienen: EN ISO 354 mide el sistema material + espesor + montaje sobre una superficie de 12.08 m2.; Absorcion alpha 125 Hz: 0.15; Absorcion alpha 250 Hz: 0.35; Absorcion alpha 500 Hz: 0.8; Absorcion alpha 1000 Hz: 1.0; Absorcion alpha 2000 Hz: 1.0; Absorcion alpha 4000 Hz: 1.0
